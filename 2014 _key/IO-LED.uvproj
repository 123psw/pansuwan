# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IO-LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: GPIO.c main.c timer.c 1. LED.c KEY.c
